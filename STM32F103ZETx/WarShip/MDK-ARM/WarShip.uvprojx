# Keil uVision project WarShip.uvprojx, settings and files
target WarShip (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WarShip +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,OS_SUPPORT
  c misc: --C99
  c include: ../Inc;             ../Drivers/STM32F1xx_HAL_Driver/Inc;             ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;             ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;             ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;             ../Middlewares/Third_Party/FreeRTOS/Source/include;             ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;             ../Drivers/CMSIS/Include;             ..\User;             ..\User\STemWin\inc;             ..\User\STemWin\Config
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x68000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: gpio.c iwdg.c rtc.c stm32f1xx_hal_timebase_TIM.c i2c.c dma.c stm32f1xx_it.c fsmc.c usart.c freertos.c spi.c main.c stm32f1xx_hal_msp.c adc.c crc.c tim.c
    ../User/: cpu_utils.c user.c oled.c lgdp4535.c lcddev.c cmdline.c infrared.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_sram.c stm32f1xx_hal_adc.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rtc.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c stm32f1xx_hal_flash.c stm32f1xx_hal_rcc.c stm32f1xx_hal_crc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c tasks.c event_groups.c queue.c timers.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_5.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group STemwin
    ../User/STemWin/OS/: GUI_X_OS.c
    ../User/STemWin/Lib/: STemWin528_CM3_OS_Keil.lib
    ../User/STemWin/Config/: LCDConf_FlexColor_Template.c GUIConf.c
    ../User/: WindowDLG.c
software components: CMSIS:CORE 4.1.0
